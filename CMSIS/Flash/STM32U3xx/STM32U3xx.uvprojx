# Keil uVision project STM32U3xx.uvprojx, settings and files
target STM323xx_512K_NSecure (6210000::V6.21::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: STM32U3xx_512K_0800
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: FLASH_MEM, STM32U3xx_512K_0800
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32U3xx_512K_Secure (6210000::V6.21::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: STM32U3xx_512K_0C00
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: FLASH_MEM, STM32U3xx_512K_0C00
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32U3xx_1M_NSecure (6210000::V6.21::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: STM32U3xx_1M_0800
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: FLASH_MEM,STM32U3xx_1M_0800
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32U3xx_1M_Secure (6210000::V6.21::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: STM32U3xx_1M_0C00
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: FLASH_MEM,STM32U3xx_1M_0C00
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
